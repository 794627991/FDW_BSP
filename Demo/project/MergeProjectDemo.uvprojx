# Keil uVision project MergeProjectDemo.uvprojx, settings and files
target APP (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: FM33G04X FMSH
  pack: Keil.FM33G0XX_DFP.0.3.03G
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: app +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __VTOR_PRESENT,__DEBUG
  c include: ..\api_cfg;..\api;..\app_user;..\device;..\device\Include;..\device\Source\ARM;..\lib;..\other\cjson;..\other\GUI\Config;..\other\GUI\Core;..\other\GUI\LCDDriver;..\other\GUI\Widget;..\other\GUI\WM;..\other\gzip;..\other\minilzo-2.10;..\other\quicklz;..\other\ucosiii\ports;..\other\ucosiii\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group api_cfg
    ../api_cfg/: API_CFG.h user_io_def.h
    ../other/ucosiii/ports/: os_app_hooks.h os_cfg.h os_cfg_app.h os_cpu.h
  group app_user
    ../app_user/: event.c main.c
  group boot_user
    ../boot_user/: interrupt.c uart.c bootmain.c
  group api
    ../api/: adc_api.c aes_api.c API_Exp.c bootfixapi.c bsp_user_lib.c convert.c etim_api.c flash_api.c iic_api.c interrupt_api.c iot_bc28_35_95.c iot_bc260.c iot_n23.c iotnew_api.c lcd_api.c lptim_api.c lpuart_api.c malloc.c myprintf.c rtc_api.c sha256.c system.c uart_api.c uarttimeout.c ucosinit.c useevent.c
  group lib
    ../lib/: fm33g0xx_aes.c fm33g0xx_anac.c fm33g0xx_btim.c fm33g0xx_crc.c fm33g0xx_dma.c fm33g0xx_etim.c fm33g0xx_flash.c fm33g0xx_gpio.c fm33g0xx_hspi.c fm33g0xx_i2c.c fm33g0xx_iwdt.c fm33g0xx_lcd.c fm33g0xx_lptim.c fm33g0xx_lpuart.c fm33g0xx_pmu.c fm33g0xx_rcc.c fm33g0xx_rtc.c fm33g0xx_scu.c fm33g0xx_spi.c fm33g0xx_trng.c fm33g0xx_u7816.c fm33g0xx_uart.c fm33g0xx_wwdt.c
  group device
    ../device/Source/: system_FM33G0XX_app.c system_FM33G0XX_boot.c
    ../device/Source/ARM/: startup_FM33G0XX.s
  group ucosiii_cfg
    ../other/ucosiii/ports/: os_cfg.h os_cfg_app.h cpu_cfg.h
  group ucosiii_src
    ../other/ucosiii/ports/: cpu_a.asm cpu_c.c cpu_core.c os_cpu_a.s os_cpu_c.c
  group ucosiii_port
    ../other/ucosiii/src/: lib_ascii.c lib_math.c lib_mem.c lib_str.c os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group cjson
    ../other/cjson/: cJSON.c
  group minilzo
    ../other/minilzo-2.10/: minilzo.c
  group quicklz
    ../other/quicklz/: quicklz.c
  group gui_cfg
    ../other/GUI/Config/: GUIConf.h GUITouchConf.h LCDConf.h
  group gui_lcd_driver
    ../other/GUI/LCDDriver/: 12864.c LCDMem.c LCDNull.c LCDTemplate.c LCDWin.c
  group gui_x
    ../other/GUI/GUI_X/: GUI_X_uCOSIII.c
  group gui_core
    ../other/GUI/Core/: GUI__AddSpaceHex.c GUI__Arabic.c GUI__CalcTextRect.c GUI__DivideRound.c GUI__DivideRound32.c GUI__DrawBitmap16bpp.c GUI__GetCursorPos.c GUI__GetFontSizeY.c GUI__GetNumChars.c GUI__HandleEOLine.c GUI__IntersectRect.c GUI__IntersectRects.c GUI__memset.c GUI__memset16.c GUI__Read.c GUI__ReduceRect.c GUI__SetText.c GUI__strcmp.c GUI__strlen.c GUI__Wrap.c GUI_AddBin.c GUI_AddDec.c GUI_AddDecMin.c GUI_AddDecShift.c GUI_AddHex.c GUI_AddKeyMsgHook.c GUI_ALLOC_AllocInit.c GUI_ALLOC_AllocZero.c GUI_BMP.c GUI_BMP_Serialize.c GUI_CalcColorDist.c GUI_ClearRectEx.c GUI_Color2VisColor.c GUI_CursorArrowL.c GUI_CursorArrowLI.c GUI_CursorArrowLPx.c GUI_CursorArrowM.c GUI_CursorArrowMI.c GUI_CursorArrowMPx.c GUI_CursorArrowS.c GUI_CursorArrowSI.c GUI_CursorArrowSPx.c GUI_CursorCrossL.c GUI_CursorCrossLI.c GUI_CursorCrossLPx.c GUI_CursorCrossM.c GUI_CursorCrossMI.c GUI_CursorCrossMPx.c GUI_CursorCrossS.c GUI_CursorCrossSI.c GUI_CursorCrossSPx.c GUI_CursorHeaderM.c GUI_CursorHeaderMI.c GUI_CursorHeaderMPx.c GUI_CursorPal.c GUI_CursorPalI.c GUI_DispBin.c GUI_DispCEOL.c GUI_DispChar.c GUI_DispChars.c GUI_DispHex.c GUI_DispString.c GUI_DispStringAt.c GUI_DispStringAtCEOL.c GUI_DispStringHCenter.c GUI_DispStringInRect.c GUI_DispStringInRectEx.c GUI_DispStringInRectWrap.c GUI_DispStringLen.c GUI_DrawBitmap.c GUI_DrawBitmap_555.c GUI_DrawBitmap_565.c GUI_DrawBitmap_888.c GUI_DrawBitmapEx.c GUI_DrawBitmapExp.c GUI_DrawBitmapMag.c GUI_DrawFocusRect.c GUI_DrawGraph.c GUI_DrawGraphEx.c GUI_DrawHLine.c GUI_DrawLine.c GUI_DrawPie.c GUI_DrawPixel.c GUI_DrawPoint.c GUI_DrawPolygon.c GUI_DrawPolyline.c GUI_DrawRectEx.c GUI_DrawVLine.c GUI_ErrorOut.c GUI_Exec.c GUI_FillPolygon.c GUI_FillRect.c GUI_FillRectEx.c GUI_GetBitmapPixelColor.c GUI_GetBitmapPixelIndex.c GUI_GetClientRect.c GUI_GetColor.c GUI_GetDispPos.c GUI_GetDrawMode.c GUI_GetFont.c GUI_GetFontInfo.c GUI_GetFontSizeY.c GUI_GetLineStyle.c GUI_GetOrg.c GUI_GetStringDistX.c GUI_GetTextAlign.c GUI_GetTextExtend.c GUI_GetTextMode.c GUI_GetVersionString.c GUI_GetYSizeOfFont.c GUI_GIF.c GUI_Goto.c GUI_InitLUT.c GUI_InvertRect.c GUI_IsInFont.c GUI_LCD_API.c GUI_Log.c GUI_MergeRect.c GUI_MOUSE.c GUI_MOUSE_DriverPS2.c GUI_MoveRect.c GUI_OnKey.c GUI_Pen.c GUI_PID.c GUI_RectsIntersect.c GUI_SaveContext.c GUI_ScreenSize.c GUI_SelectLayer.c GUI_SelectLCD.c GUI_SetClipRect.c GUI_SetColor.c GUI_SetColorIndex.c GUI_SetDecChar.c GUI_SetDefault.c GUI_SetDrawMode.c GUI_SetFont.c GUI_SetLBorder.c GUI_SetLineStyle.c GUI_SetLUTColor.c GUI_SetLUTColorEx.c GUI_SetLUTEntry.c GUI_SetOrg.c GUI_SetPixelIndex.c GUI_SetTextAlign.c GUI_SetTextMode.c GUI_SetTextStyle.c GUI_SIF.c GUI_SIF_Prop.c GUI_TOUCH.c GUI_TOUCH_DriverAnalog.c GUI_TOUCH_StoreState.c GUI_TOUCH_StoreUnstable.c GUI_UC.c GUI_UC_ConvertUC2UTF8.c GUI_UC_ConvertUTF82UC.c GUI_UC_DispString.c GUI_UC_EncodeNone.c GUI_UC_EncodeUTF8.c GUI_WaitEvent.c GUI_WaitKey.c GUI_Warn.c GUI2DLib.c GUIAlloc.c GUIArc.c GUIChar.c GUICharLine.c GUICharM.c GUICharP.c GUICirc.c GUIColor2Index.c GUICore.c GUICurs.c GUIEncJS.c GUIIndex2Color.c GUIPolyE.c GUIPolyM.c GUIPolyR.c GUIRealloc.c GUIStream.c GUITask.c GUITime.c GUITimer.c GUIUC0.c GUIVal.c GUIValf.c LCD.c LCD_DrawVLine.c LCD_GetColorIndex.c LCD_GetEx.c LCD_GetNumDisplays.c LCD_GetPixelColor.c LCD_Index2ColorEx.c LCD_L0_Generic.c LCD_Mirror.c LCD_MixColors256.c LCD_ReadRect.c LCD_Rotate180.c LCD_RotateCCW.c LCD_RotateCW.c LCD_SelectLCD.c LCD_SetAPI.c LCD_SetClipRectEx.c LCD_UpdateColorIndices.c LCDAA.c LCDColor.c LCDGetP.c LCDInfo.c LCDInfo0.c LCDInfo1.c LCDL0Delta.c LCDL0Mag.c LCDP1.c LCDP565_Index2Color.c LCDP888_Index2Color.c LCDPM565_Index2Color.c LCDPM888_Index2Color.c LCDRLE4.c LCDRLE8.c LCDRLE16.c
  group gui_convert_color
    ../other/GUI/ConvertColor/: LCDP111.c LCDP222.c LCDP233.c LCDP323.c LCDP332.c LCDP444_12.c LCDP444_12_1.c LCDP444_16.c LCDP555.c LCDP556.c LCDP565.c LCDP655.c LCDP666.c LCDP888.c LCDP8666.c LCDP8666_1.c LCDPM233.c LCDPM323.c LCDPM332.c LCDPM444_12.c LCDPM444_16.c LCDPM555.c LCDPM556.c LCDPM565.c LCDPM655.c LCDPM666.c LCDPM888.c
  group gui_convert_mono
    ../other/GUI/ConvertMono/: LCDP0.c LCDP2.c LCDP4.c
  group gui_font
    ../other/GUI/Font/: F4x6.c F6x8.c F08_1.c F08_ASCII.c F8x8.c F8x10_ASCII.c F8x12_ASCII.c F8x13_1.c F8x13_ASCII.c F8x15B_1.c F8x15B_ASCII.c F8x16.c F10_1.c F10_ASCII.c F10S_1.c F10S_ASCII.c F13_1.c F13_ASCII.c F13B_1.c F13B_ASCII.c F13H_1.c F13H_ASCII.c F13HB_1.c F13HB_ASCII.c F16_1.c F16_1HK.c F16_ASCII.c F16_HK.c F16B_1.c F16B_ASCII.c F24_1.c F24_ASCII.c F24B_1.c F24B_ASCII.c F32_1.c F32_ASCII.c F32B_1.c F32B_ASCII.c FComic18B_1.c FComic18B_ASCII.c FComic24B_1.c FComic24B_ASCII.c FD24x32.c FD32.c FD36x48.c FD48.c FD48x64.c FD60x80.c FD64.c FD80.c
  group gui_wm
    ../other/GUI/WM/: WM.c WM__ForEachDesc.c WM__GetFirstSibling.c WM__GetFocussedChild.c WM__GetLastSibling.c WM__GetOrg_AA.c WM__GetPrevSibling.c WM__IsAncestor.c WM__IsChild.c WM__IsEnabled.c WM__NotifyVisChanged.c WM__Screen2Client.c WM__SendMessage.c WM__SendMessageIfEnabled.c WM__SendMessageNoPara.c WM__UpdateChildPositions.c WM_AttachWindow.c WM_BringToBottom.c WM_BringToTop.c WM_Broadcast.c WM_CheckScrollPos.c WM_CriticalHandle.c WM_DIAG.c WM_EnableWindow.c WM_ForEachDesc.c WM_GetBkColor.c WM_GetCallback.c WM_GetClientRect.c WM_GetClientWindow.c WM_GetDesktopWindow.c WM_GetDesktopWindowEx.c WM_GetDiagInfo.c WM_GetDialogItem.c WM_GetFirstChild.c WM_GetFlags.c WM_GetFocussedWindow.c WM_GetId.c WM_GetInsideRect.c WM_GetInsideRectExScrollbar.c WM_GetInvalidRect.c WM_GetNextSibling.c WM_GetOrg.c WM_GetParent.c WM_GetPrevSibling.c WM_GetScrollbar.c WM_GetScrollPartner.c WM_GetScrollPos.c WM_GetScrollState.c WM_GetWindowRect.c WM_GetWindowSize.c WM_HasCaptured.c WM_HasFocus.c WM_Hide.c WM_InvalidateArea.c WM_IsCompletelyVisible.c WM_IsEnabled.c WM_IsFocussable.c WM_IsVisible.c WM_IsWindow.c WM_MakeModal.c WM_Move.c WM_MoveChildTo.c WM_NotifyParent.c WM_OnKey.c WM_Paint.c WM_PaintWindowAndDescs.c WM_PID__GetPrevState.c WM_ResizeWindow.c WM_Screen2Win.c WM_SendMessageNoPara.c WM_SendToParent.c WM_SetAnchor.c WM_SetCallback.c WM_SetCapture.c WM_SetCaptureMove.c WM_SetCreateFlags.c WM_SetDesktopColor.c WM_SetFocus.c WM_SetFocusOnNextChild.c WM_SetFocusOnPrevChild.c WM_SetId.c WM_SetpfPollPID.c WM_SetScrollbar.c WM_SetScrollPos.c WM_SetScrollState.c WM_SetSize.c WM_SetTrans.c WM_SetTransState.c WM_SetUserClipRect.c WM_SetWindowPos.c WM_SetXSize.c WM_SetYSize.c WM_Show.c WM_SIM.c WM_StayOnTop.c WM_Timer.c WM_TimerExternal.c WM_UpdateWindowAndDescs.c WM_UserData.c WM_Validate.c WM_ValidateWindow.c WMMemDev.c WMTouch.c
  group gui_widget
    ../other/GUI/Widget/: BUTTON.c BUTTON__SetBitmapObj.c BUTTON_Bitmap.c BUTTON_BMP.c BUTTON_Create.c BUTTON_CreateIndirect.c BUTTON_Default.c BUTTON_Get.c BUTTON_GetBitmap.c BUTTON_IsPressed.c BUTTON_SelfDraw.c BUTTON_SetFocusColor.c BUTTON_SetTextAlign.c BUTTON_StreamedBitmap.c CHECKBOX.c CHECKBOX_Create.c CHECKBOX_CreateIndirect.c CHECKBOX_Default.c CHECKBOX_GetState.c CHECKBOX_GetText.c CHECKBOX_Image.c CHECKBOX_IsChecked.c CHECKBOX_SetBkColor.c CHECKBOX_SetBoxBkColor.c CHECKBOX_SetDefaultImage.c CHECKBOX_SetFocusColor.c CHECKBOX_SetFont.c CHECKBOX_SetImage.c CHECKBOX_SetNumStates.c CHECKBOX_SetSpacing.c CHECKBOX_SetState.c CHECKBOX_SetText.c CHECKBOX_SetTextAlign.c CHECKBOX_SetTextColor.c DIALOG.c DROPDOWN.c DROPDOWN_AddString.c DROPDOWN_Create.c DROPDOWN_CreateIndirect.c DROPDOWN_Default.c DROPDOWN_DeleteItem.c DROPDOWN_GetNumItems.c DROPDOWN_InsertString.c DROPDOWN_ItemSpacing.c DROPDOWN_SetAutoScroll.c DROPDOWN_SetBkColor.c DROPDOWN_SetColor.c DROPDOWN_SetFont.c DROPDOWN_SetScrollbarColor.c DROPDOWN_SetScrollbarWidth.c DROPDOWN_SetTextAlign.c DROPDOWN_SetTextColor.c DROPDOWN_SetTextHeight.c EDIT.c EDIT_Create.c EDIT_CreateIndirect.c EDIT_Default.c EDIT_GetCursorPixelPos.c EDIT_GetCursorPos.c EDIT_GetNumChars.c EDIT_SetCursorAtChar.c EDIT_SetFocussable.c EDIT_SetInsertMode.c EDIT_SetpfAddKeyEx.c EDIT_SetpfUpdateBuffer.c EDIT_SetSel.c EDIT_SetTextMode.c EDITBin.c EDITDec.c EDITFloat.c EDITHex.c EDITUlong.c FRAMEWIN.c FRAMEWIN__UpdateButtons.c FRAMEWIN_AddMenu.c FRAMEWIN_Button.c FRAMEWIN_ButtonClose.c FRAMEWIN_ButtonMax.c FRAMEWIN_ButtonMin.c FRAMEWIN_Create.c FRAMEWIN_CreateIndirect.c FRAMEWIN_Default.c FRAMEWIN_Get.c FRAMEWIN_IsMinMax.c FRAMEWIN_MinMaxRest.c FRAMEWIN_SetBorderSize.c FRAMEWIN_SetColors.c FRAMEWIN_SetFont.c FRAMEWIN_SetResizeable.c FRAMEWIN_SetTitleHeight.c FRAMEWIN_SetTitleVis.c GRAPH.c GRAPH_CreateIndirect.c GRAPH_DATA_XY.c GRAPH_DATA_YT.c GRAPH_SCALE.c GUI_ARRAY.c GUI_ARRAY_DeleteItem.c GUI_ARRAY_InsertItem.c GUI_ARRAY_ResizeItem.c GUI_DRAW.c GUI_DRAW_BITMAP.c GUI_DRAW_BMP.c GUI_DRAW_Self.c GUI_DRAW_STREAMED.c GUI_EditBin.c GUI_EditDec.c GUI_EditFloat.c GUI_EditHex.c GUI_EditString.c GUI_HOOK.c HEADER.c HEADER__SetDrawObj.c HEADER_Bitmap.c HEADER_BMP.c HEADER_Create.c HEADER_CreateIndirect.c HEADER_GetSel.c HEADER_SetDragLimit.c HEADER_StreamedBitmap.c LISTBOX.c LISTBOX_Create.c LISTBOX_CreateIndirect.c LISTBOX_Default.c LISTBOX_DeleteItem.c LISTBOX_Font.c LISTBOX_GetItemText.c LISTBOX_GetNumItems.c LISTBOX_GetTextAlign.c LISTBOX_InsertString.c LISTBOX_ItemDisabled.c LISTBOX_ItemSpacing.c LISTBOX_MultiSel.c LISTBOX_ScrollStep.c LISTBOX_SetAutoScroll.c LISTBOX_SetBkColor.c LISTBOX_SetOwner.c LISTBOX_SetOwnerDraw.c LISTBOX_SetScrollbarColor.c LISTBOX_SetScrollbarWidth.c LISTBOX_SetString.c LISTBOX_SetTextAlign.c LISTBOX_SetTextColor.c LISTVIEW.c LISTVIEW_Create.c LISTVIEW_CreateIndirect.c LISTVIEW_Default.c LISTVIEW_DeleteAllRows.c LISTVIEW_DeleteColumn.c LISTVIEW_DeleteRow.c LISTVIEW_DisableRow.c LISTVIEW_GetBkColor.c LISTVIEW_GetFont.c LISTVIEW_GetHeader.c LISTVIEW_GetItemText.c LISTVIEW_GetNumColumns.c LISTVIEW_GetNumRows.c LISTVIEW_GetSel.c LISTVIEW_GetTextColor.c LISTVIEW_InsertRow.c LISTVIEW_SetAutoScroll.c LISTVIEW_SetBkColor.c LISTVIEW_SetColumnWidth.c LISTVIEW_SetFont.c LISTVIEW_SetGridVis.c LISTVIEW_SetItemColor.c LISTVIEW_SetItemText.c LISTVIEW_SetLBorder.c LISTVIEW_SetRBorder.c LISTVIEW_SetRowHeight.c LISTVIEW_SetSel.c LISTVIEW_SetSort.c LISTVIEW_SetTextAlign.c LISTVIEW_SetTextColor.c LISTVIEW_UserData.c MENU.c MENU__FindItem.c MENU_Attach.c MENU_CreateIndirect.c MENU_Default.c MENU_DeleteItem.c MENU_DisableItem.c MENU_EnableItem.c MENU_GetItem.c MENU_GetItemText.c MENU_GetNumItems.c MENU_InsertItem.c MENU_Popup.c MENU_SetBkColor.c MENU_SetBorderSize.c MENU_SetFont.c MENU_SetItem.c MENU_SetTextColor.c MESSAGEBOX.c MULTIEDIT.c MULTIEDIT_Create.c MULTIEDIT_CreateIndirect.c MULTIPAGE.c MULTIPAGE_Create.c MULTIPAGE_CreateIndirect.c MULTIPAGE_Default.c PROGBAR.c PROGBAR_Create.c PROGBAR_CreateIndirect.c PROGBAR_SetBarColor.c PROGBAR_SetFont.c PROGBAR_SetMinMax.c PROGBAR_SetText.c PROGBAR_SetTextAlign.c PROGBAR_SetTextColor.c PROGBAR_SetTextPos.c RADIO.c RADIO_Create.c RADIO_CreateIndirect.c RADIO_Default.c RADIO_GetText.c RADIO_Image.c RADIO_SetBkColor.c RADIO_SetDefaultImage.c RADIO_SetFocusColor.c RADIO_SetFont.c RADIO_SetGroupId.c RADIO_SetImage.c RADIO_SetText.c RADIO_SetTextColor.c SCROLLBAR.c SCROLLBAR_Create.c SCROLLBAR_CreateIndirect.c SCROLLBAR_Defaults.c SCROLLBAR_GetValue.c SCROLLBAR_SetColor.c SCROLLBAR_SetWidth.c SLIDER.c SLIDER_Create.c SLIDER_CreateIndirect.c SLIDER_Default.c SLIDER_SetFocusColor.c TEXT.c TEXT_Create.c TEXT_CreateIndirect.c TEXT_Default.c TEXT_SetBkColor.c TEXT_SetFont.c TEXT_SetText.c TEXT_SetTextAlign.c TEXT_SetTextColor.c TEXT_SetWrapMode.c WIDGET.c WIDGET_Effect_3D.c WIDGET_Effect_3D1L.c WIDGET_Effect_3D2L.c WIDGET_Effect_None.c WIDGET_Effect_Simple.c WIDGET_FillStringInRect.c WIDGET_SetEffect.c WIDGET_SetWidth.c WINDOW.c WINDOW_Default.c
  group gui_multi_layer
    ../other/GUI/MultiLayer/: LCD_1.c LCD_2.c LCD_3.c LCD_4.c
  group gui_mem_dev
    ../other/GUI/MemDev/: GUIDEV.c GUIDEV_1.c GUIDEV_8.c GUIDEV_16.c GUIDEV_AA.c GUIDEV_Auto.c GUIDEV_Banding.c GUIDEV_Clear.c GUIDEV_CmpWithLCD.c GUIDEV_CopyFromLCD.c GUIDEV_CreateFixed.c GUIDEV_GetDataPtr.c GUIDEV_GetXSize.c GUIDEV_GetYSize.c GUIDEV_Measure.c GUIDEV_ReduceYSize.c GUIDEV_SetOrg.c GUIDEV_Usage.c GUIDEV_UsageBM.c GUIDEV_Write.c GUIDEV_WriteAlpha.c GUIDEV_WriteEx.c GUIDEV_XY2PTR.c
  group gui_AntiAlias
    ../other/GUI/AntiAlias/: GUIAAArc.c GUIAAChar.c GUIAAChar2.c GUIAAChar4.c GUIAACircle.c GUIAALib.c GUIAALine.c GUIAAPoly.c GUIAAPolyOut.c
target BOOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: FM33G04X FMSH
  pack: Keil.FM33G0XX_DFP.0.3.03G
  cpu: as above
  output: boot +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __VTOR_PRESENT,__DEBUG
  c misc: --diag_suppress 1296
  c include: ..\api_cfg;..\api;..\boot_user;..\device\Include;..\device\Source;..\lib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
software components: CMSIS:CORE 5.4.0
